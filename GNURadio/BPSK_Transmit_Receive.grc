options:
  parameters:
    author: daniel-mayer
    generate_options: qt_gui
    id: BPSK_Transmit_Receive
    output_language: python
    title: BPSK_Transmit_Receive
  states: {}

blocks:
- name: bpsk_constellation
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.5, 0.5]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: '900000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: signalhound_bw
  id: variable
  parameters:
    comment: |-
      The sampling frequency and bandwidth of the received (SignalHound)
      stream *after* all resampling has been applied.
      Note that this will be equal to the initial filtering applied to the SignalHound stream.
    value: 5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: |-
      Send random signals to simulate a 
      real communication (e.g. a compressed transmission).
    max: '2'
    min: '0'
    num_samps: '100000000'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: center_frequency
    filename: tx_out
    hw_info: Pre-Transmission Raw IQ data
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: blocks_sigmf_sink_minimal_0_0
  id: blocks_sigmf_sink_minimal
  parameters:
    center_freq: center_frequency
    filename: rx_out_SignalHound
    hw_info: SignalHound BB60A
    sample_rate: signalhound_bw
    type: complex float (fc32_le)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      - Includes integer-to-symbol and RRC pulse-shaping filter.
      - 'Excess BW' = RRC rolloff factor ('alpha')
      - 4 samples/symbol is standard
    constellation: bpsk_constellation
    differential: 'False'
    excess_bw: '0.25'
    samples_per_symbol: sps
  states: {}
- name: note_0
  id: note
  parameters:
    note: TRANSMIT COMPONENT
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: RECEIVE COMPONENT
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: TX
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: signalhound_bw
    fc: '0'
    fftsize: '1024'
    name: RX
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Post-Filter
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: signalhound_bw
    fc: '0'
    fftsize: '1024'
    name: RX
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 5e6
    fc: '0'
    fftsize: '1024'
    name: TX
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      The BB60 samples at 40 MSPS. We want 5 MSPS to match the source; hence, we decimate by 8.
       This is safe because the 'bandwidth' parameter of the Signal Hound LPFs the zero-centered signal 
      with cutoff of 2.5 MSPS (bandwidth of 5 MSPS).
    decim: '8'
    interp: '1'
    type: ccc
  states: {}
- name: signal_hound_bb_series_0
  id: signal_hound_bb_series
  parameters:
    bandwidth: signalhound_bw
    center: 900e6
    comment: |-
      - Samples at 40 MSPS, always.
      - Decimation completed with a Rational Resampler later to make the implementation clearer.
      - Bandwidth = LPF applied to the samples; DOES NOT relate to the sampling rate.
    decimation: '1'
    purge: 'False'
    reflevel: '-20'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '900000000'
    comment: |-
      - 'Stream channels' set to 1 to use the correct TX/RX daughterboard.
      - SPS sets the overall sampling rate of the transmit flowgraph.
    gain0: '35'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_sigmf_sink_minimal_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [signal_hound_bb_series_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
